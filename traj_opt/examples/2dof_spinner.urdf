Commit message: isolate problem with spheres vs capsules

File: traj_opt/examples/2dof_spinner.urdf (robot description, URDF)
Before this commit: robot spinner, 4 links, 4 joints
Links:
- link finger_two: geometry collision capsule length=0.9 radius=0.05; visual capsule length=0.9 radius=0.05
